# Keil uVision project demo.uvprojx, settings and files
target FRDM-KL05ZJ (6140001::V6.14.1::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c pit.c HC_SR04.c Nokia5110.c speaker.c delay.c bitmap.c font.c delay_us.c
  group inc
    ./: frdm_bsp.h pit.h HC_SR04.h Nokia5110.h speaker.h sinus.h delay.h bitmap.h font.h delay_us.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
